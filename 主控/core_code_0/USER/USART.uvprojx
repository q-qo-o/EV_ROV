# Keil uVision project USART.uvprojx, settings and files
target USART (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\usart1;..\FWLIB\inc;..\HARDWARE\usart6;..\HARDWARE\flash;..\HARDWARE\TIM;..\HARDWARE\PID;..\HARDWARE\ms5805;..\HARDWARE\IIC;..\HARDWARE\usart2_MEMS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/usart1/: usart.c
    ../HARDWARE/flash/: flash.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/TIM/: tim.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/ms5805/: ms5805.c
    ../HARDWARE/usart2_MEMS/: usart2_MEMS.c
    ../HARDWARE/usart6/: usart6.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_flash.c stm32f4xx_dma.c stm32f4xx_tim.c
  group README
    ../: readme.txt
